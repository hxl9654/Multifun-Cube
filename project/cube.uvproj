# Keil uVision project cube.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: cube +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ../source/: main.c 18B20.c 74hc595.c DS1302.c iic.c key.c uart.c 24C512.c config.h STC12C5A.h WatchDogTimer.c
